# Keil uVision project Project.uvprojx, settings and files
target STM32F40_41xxx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F40_41xxx
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Ethercat\Inc;..\Ethercat\src;..\User;..\..\Libraries\CMSIS\Include;..\User\BEEP;..\User\delay;..\User\OLED;..\User\DMA;..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group Doc
    ../: readme.txt
  group User
    ../: stm32f4xx_it.c
  group Hardware
    ../Ethercat/port/: el9800hw.c
    ../User/: Timer.c EXIT.c SPI1.c ADC1.c
    ../User/BEEP/: beep.c
    ../User/delay/: delay.c
    ../User/OLED/: oled.c
    ../User/DMA/: dma.c
    ../User/usart/: usart.c
  group Src
    ../Ethercat/src/: foeappl.c el9800appl.c coeappl.c ecatappl.c aoeappl.c
  group Stack
    ../Ethercat/src/: ecataoe.c ecatcoe.c bootmode.c diag.c ecatfoe.c ecateoe.c ecatslv.c ecatsoe.c emcy.c eoeappl.c mailbox.c objdef.c sdoserv.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
